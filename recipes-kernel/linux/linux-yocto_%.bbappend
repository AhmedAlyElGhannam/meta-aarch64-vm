FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://virtio-qnxguest.cfg"

